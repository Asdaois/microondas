#include "p16f1787.inc"
; CONFIG1
; Use la misma configuración de los anexos referentes al 1787 anexo 2.1
; Variables
DISS_L equ 0x20
DISS_H equ 0x21
DISM_L equ 0x22
DISM_H equ 0x23
CONT0 equ 0x24
CONT1 equ 0x25
SEG_L equ 0x26
SEG_H equ 0x27
MIN_L equ 0x28
MIN_H equ 0x29
COND equ 0x2A
AUX equ 0x2B
DEC equ 0x2C
ESTADO equ 0x2D
WAUX equ 0x2E
COND2 equ 0x2F
DEC2 equ 0x30

goto PRINCIPAL
org 04
goto INTERRUPCION
PRINCIPAL:
bsf STATUS,RP0
movlw 0xF1
movwf TRISB
movlw 0x01
movwf TRISD
movlw 0x0C
movwf TRISC
movlw 0x04
movwf OPTION_REG
bcf STATUS,RP0
movlw .200
movwf DEC
clrf DEC2
clrf COND2
clrf PORTB
clrf COND
clrf SEG_L
clrf SEG_H
clrf MIN_L
clrf MIN_H
movlw 0x80
movwf DISS_L
movwf DISS_H
movwf DISM_L
movwf DISM_H
movlw 0x20
movwf FSR
movlw 0x10
movwf PORTC
movlw 0xA0
movwf INTCON
CICLO2
btfss PORTB,4
goto CICLO2
btfss PORTB,5
goto CICLO2
btfss PORTB,6
goto CICLO2
btfss PORTB,7
goto CICLO2
CICLO
btfss INTCON,0
goto CICLO
call RETARDO
movlw 0xFC ; 11111100 columna 
movwf PORTB
btfsc PORTB,4 ; uno
goto $+3
movlw 0x01
goto CONINT
btfsc PORTB,5 ; cuatro
goto $+3
movlw 0x04
goto CONINT
btfsc PORTB,6 ; siete
goto $+3
movlw 0x07
goto CONINT
btfss PORTB,7 ; *
goto RESET
movlw 0xFA ;1111010 segunda columna
movwf PORTB
btfsc PORTB,4 ; dos
goto $+3
movlw 0x02
goto CONINT
btfsc PORTB,5 ; cinco
goto $+3
movlw 0x05
goto CONINT
btfsc PORTB,6 ; ocho
goto $+3
movlw 0x08
goto CONINT
btfsc PORTB,7 ; cero
goto $+3
movlw 0x00
goto CONINT
movlw 0xF6 ; 11110110 tercera columna
movwf PORTB
btfsc PORTB,4 ;tres
goto $+3
movlw 0x03
goto CONINT
btfsc PORTB,5 ; seis
goto $+3
movlw 0x06
goto CONINT
btfsc PORTB,6 ; nueve
goto $+3
movlw 0x09
goto CONINT
btfsc PORTB,7 ; #
goto FIN
bcf INTCON,0
bsf COND,0
bsf COND,1
movf SEG_L,W
addwf SEG_H,W
addwf MIN_L,W
addwf MIN_H,W
btfsc STATUS,Z
goto RESET
goto STPS
CONINT
movwf AUX
movf MIN_L,W
movwf MIN_H
movf SEG_H,W
movwf MIN_L
movf SEG_L,W
movwf SEG_H
movf AUX,W
movwf SEG_L
call ASIGNAR
FIN clrf PORTB
bcf INTCON,0
goto CICLO2
BCD_7SEG
addwf PCL,F
retlw 0x80
retlw 0xF2
retlw 0x48
retlw 0x60
retlw 0x32
retlw 0x24
retlw 0x04
retlw 0xF0
retlw 0x00
retlw 0x30
INTERRUPCION:
movwf WAUX
swapf STATUS,W
movwf ESTADO
movlw .100
addwf TMR0,F
btfss COND2,0
goto SIG
decfsz DEC2,F
goto $+4
bcf COND2,0
bcf PORTC,0
goto SIG
movlw .200
xorwf DEC2,W
btfsc STATUS,Z
bcf PORTC,0
movlw .150
xorwf DEC2,W
btfsc STATUS,Z
bsf PORTC,0
movlw .100
xorwf DEC2,W
btfsc STATUS,Z
bcf PORTC,0
movlw .50
xorwf DEC2,W
btfsc STATUS,Z
bsf PORTC,0
SIG
btfss COND,1
goto CONTINUAR1
movf SEG_L,W
addwf SEG_H,W
addwf MIN_L,W
addwf MIN_H,W
btfsc STATUS,Z
goto IRFIN
decfsz DEC,F
goto CONTINUAR1
movlw .200
movwf DEC
movlw 0
xorwf SEG_L,W
btfsc STATUS,Z
goto $+3
decf SEG_L,F
goto CONTINUAR2
movlw .9
movwf SEG_L
movlw 0
xorwf SEG_H,W
btfsc STATUS,Z
goto $+3
decf SEG_H,F
goto CONTINUAR2
movlw .5
movwf SEG_H
movlw 0
xorwf MIN_L,W
btfsc STATUS,Z
goto $+3
decf MIN_L,F
goto CONTINUAR2
movlw .9
movwf MIN_L
movlw 0
xorwf MIN_H,W
btfsc STATUS,Z
goto $+3
decf MIN_H,F
goto CONTINUAR2
IRFIN
bsf PORTC,0
clrf PORTB
bcf INTCON,0
clrf COND
bsf COND2,0
movlw .250
movwf DEC2
goto CONTINUAR1
CONTINUAR2
call ASIGNAR
CONTINUAR1
incf FSR,F
movlw 0x24
xorwf FSR,W
btfss STATUS,Z
goto $+3
movlw 0x20
movwf FSR
btfss PORTC,4
goto $+4
bcf PORTC,4
bsf PORTC,5
goto CON_COR
btfss PORTC,5
goto $+4
bcf PORTC,5
bsf PORTC,6
goto CON_COR
btfss PORTC,6
goto $+4
bcf PORTC,6
bsf PORTC,7
goto CON_COR
bcf PORTC,7
bsf PORTC,4
CON_COR
movf INDF,W
movwf PORTD
bcf INTCON,2
swapf ESTADO,W
movwf STATUS
swapf WAUX,F
swapf WAUX,W
retfie
RESET
bcf PORTC,1
clrf COND
clrf SEG_L
clrf SEG_H
clrf MIN_L
clrf MIN_H
movlw .200
movwf DEC
movlw 0
goto CONINT
STPS
bsf PORTC,1
clrf PORTB
COND_FINAL
btfss COND,0
goto FINAL
btfss PORTB,4
goto COND_FINAL
btfss PORTB,5
goto COND_FINAL
btfss PORTB,6
goto COND_FINAL
btfss PORTB,7
goto COND_FINAL
bcf INTCON,0
btfss COND,0
goto FINAL
btfss INTCON,0
goto $-3
call RETARDO
movlw 0xFC
movwf PORTB
btfss PORTB,7
goto RESET
movlw 0xF6
movwf PORTB
btfsc PORTB,7
goto STPS
bcf INTCON,0
bcf COND,1
PAUSA
bcf PORTC,1
clrf PORTB
PAUSA_1
btfss PORTB,4
goto PAUSA_1
btfss PORTB,5
goto PAUSA_1
btfss PORTB,6
goto PAUSA_1
btfss PORTB,7
goto PAUSA_1
bcf INTCON,0
btfss INTCON,0
goto $-1
call RETARDO
movlw 0xFC
movwf PORTB
btfss PORTB,7
goto RESET
movlw 0xF6
movwf PORTB
btfsc PORTB,7
goto PAUSA
bcf INTCON,0
bsf COND,1
goto STPS
FINAL
bcf PORTC,1
movlw 0x42
movwf DISS_L
movlw 0x56
movwf DISS_H
movlw 0x0C
movwf DISM_L
movlw 0xFF
movwf DISM_H
clrf PORTB
FINAL_1
btfss PORTB,4
goto FINAL_1
btfss PORTB,5
goto FINAL_1
btfss PORTB,6
goto FINAL_1
btfss PORTB,7
goto FINAL_1
bcf INTCON,0
btfss INTCON,0
goto $-1
call RETARDO
movlw 0xFC
movwf PORTB
btfsc PORTB,7
goto FINAL
bcf INTCON,0
goto RESET
RETARDO
movlw 0x19
movwf CONT0
movlw 0xFF
movwf CONT1
decfsz CONT1,F
goto $-1
decfsz CONT0,F
goto $-5
return
ASIGNAR
movf SEG_L,W
call BCD_7SEG
movwf DISS_L
movf SEG_H,W
call BCD_7SEG
movwf DISS_H
movf MIN_L,W
call BCD_7SEG
movwf DISM_L
movf MIN_H,W
call BCD_7SEG
movwf DISM_H
return
end